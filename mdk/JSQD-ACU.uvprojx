# Keil uVision project JSQD-ACU.uvprojx, settings and files
target JSQD-ACU (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: JSQD-ACU-AES16D +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\user\Beep;..\user\EEPROM;..\user\IIC;..\user\Key;..\user\LCD_RS232;..\user\LED;..\user\Motor;..\user\Relay;..\user\Timer;..\user\WDG;..\STM32F10x_StdPeriph_Driver\inc;..\user;..\CMSIS\CM3\CoreSupport;..\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\user\data;..\user\delay;..\user\JTAG_SWD;..\user\sys;..\user\usart;..\user\Main_AES16B;..\user\Main_AMS16B;..\user\Main_FAR;..\user\Main_FAS;..\user\Main_HAS;..\user\Main_FAS_V2;..\user\Main_AES16D;..\user\Main_ADS16;..\user\Main_AES16A;..\user\Main_AMS16D;..\user\Main_AES16F;..\user\Main_AMS16B;..\user\PWM;..\user\Output;..\user\Main_Gateway;..\user\Input;..\user\actionstatus;..\user\network;..\user\i2c-pcf8574;..\user\24C256;..\user\Auto_Locate;..\user\Laser
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group user
    ../user/: main.c stm32f10x_it.c system_stm32f10x.c Sys_Init.c
    ../user/Beep/: Beep.c
    ../user/Key/: Key.c
    ../user/LED/: led.c
    ../user/Timer/: timer.c
    ../user/WDG/: wdg.c
    ../user/delay/: delay.c
    ../user/sys/: sys.c
    ../user/Output/: output.c
    ../user/PWM/: pwm.c
    ../user/Input/: input.c
    ../user/actionstatus/: Action_Status.c
    ../user/network/: network.c
    ../user/LCD_RS232/: LCD_RS232.c
    ../user/i2c-pcf8574/: i2c.c
    ../user/24C256/: 24c256.c
    ../user/Auto_Locate/: Auto_Locate.c
    ../user/Laser/: Laser.c
  group lib
    ../STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group cmsis
    ../CMSIS/CM3/CoreSupport/: core_cm3.c
  group setup
    ../CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
software components: CMSIS:CORE 5.0.1
